SUMMARY = "A qemuarma9 auto perf image."

LICENSE = "MIT"

inherit core-image

