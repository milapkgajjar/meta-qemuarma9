SUMMARY = "A qemuarma9 auto image."

LICENSE = "MIT"

inherit core-image

